Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: fc61487c-ec4c-410d-bf1e-4d68afe23d64, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T23:13:36+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11503300_USA_F2412Vi:37241201_USA_11503300_F2412Vi, (2)
In: Default
Type - Material: z_Miele_Design_GRGR, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass Black, z_Miele_Connection_Water_IN, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 451 mm; Height: 2125 mm; Depth: 608 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 37241201_USA_11503300_F2412Vi; sets with these values: 2

# IfcDistributionPort, Port_358389_1
Description: Flow; FlowDirection: SOURCEANDSINK
